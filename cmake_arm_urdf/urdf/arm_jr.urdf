Commit message: modify urdf

File: cmake_arm_urdf/urdf/arm_jr.urdf (robot description, URDF)
Before this commit: robot arm_jr, 7 links, 6 joints
Links:
- added link tool_link
Joints:
- added joint tool_joint: type fixed, parent link5, child tool_link, origin xyz=0 0.05 0 rpy=0 0 0
